# Keil uVision project FIC628.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80/87C58 Intel
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF) CLOCK(24000000)
  output: FIC628 +hex
  AfterMake: .\make.bat
  c flags: Optimize=9
  c include: ..\Code\CHIP\INCLUDE;..\Code\CORE\INCLUDE;..\Code\OEM\13CRIX\INCLUDE
  link misc: BANK0(?PR?HOOK_ECRETUNRMAINFUNCKEEPCONDITION?OEM_INIT(0x9000),?PR?FLASHECCODE?CORE_FLASH(0xFE00), ?PR?RAMCODE?CORE_FLASH(0xFF00))
NOSORTSIZE
  group CHIP
    ../Code/CHIP/: CORE_CHIPREGS.C CORE_ITEString.C
    ../Code/CORE/CORE_COMMON/: L51_BANK.A51 STARTUP.A51
  group CORE
    ../Code/Core/CORE_BANK0/: CORE_FLASH.C
    ../Code/CORE/CORE_BANK0/: CORE_SCAN.C CORE_XLT.C
    ../Code/CORE/CORE_COMMON/: CORE_ACPI.C CORE_ASM.C CORE_BITADDR.C CORE_GPIO.C CORE_HOSTIF.C CORE_INIT.C CORE_IRQ.C CORE_MAIN.C CORE_Memory.C CORE_PORT6064.C CORE_PS2.C CORE_SMBUS.C CORE_TIMERS.C
  group OEM
    ../Code/OEM/13CRIX/OEM_BANK0/: ANX7447_LIB.C OEM_6064.C OEM_ACPI.C OEM_ADC.C OEM_ASM.C OEM_BATTERY.C OEM_Debug.C OEM_ECPDM.C OEM_EVENT.C OEM_FAN.C OEM_FLASH.C OEM_GPIO.C OEM_HOSTIF.C OEM_INIT.C OEM_IRQ.C OEM_LCD.C OEM_LED.C OEM_LPC.C OEM_MAIN.C OEM_MEMORY.C OEM_PM2.C OEM_PM3.C OEM_PORT686C.C OEM_POWER.C OEM_PS2.C OEM_SCANTABS.C OEM_SMBUS.C OEM_SPI.C OEM_TIMER.C Oem_Uart.c OEM_Ver.C UCSI.C
    ../Code/OEM/13CRIX/OEM_BANK1/: OEM_BANK1_Func.C
    ../Code/OEM/13CRIX/OEM_BANK2/: OEM_BANK2_Func.C
    ../Code/OEM/13CRIX/OEM_BANK3/: OEM_BANK3_Func.C
